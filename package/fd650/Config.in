## package/fd650/Config.in
```kconfig
config BR2_PACKAGE_FD650
	bool "FD650 input driver"
	help
	  Input driver for FD650 4-button panel (shamelessly vibecoded)
```
